Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-05-18T16:09:46
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun May 18 16:09:46 2025 * Host: MichellyManno * Database: C:\Users\MICHEL~1\AppData\Local\Temp\55905fff-f54a-44d4-bb7f-38c7e782cef1\2fb5a030-920a-4fbf-a313-578172206ca9\ifc * Database version: 5507 * Database creation date: Sun May 18 16:09:42 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun May 18 16:09:42 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun May 18 16:09:42 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcFlowTerminal: 6710, Módulo_Track_KayIn_6558_6710_Nordecor_IFC:6710:329976
In: Nível 1
Type - Material: Plástico - Transparente, Metal - Alumínio - Branco, LED
Type - Cotas - Altura da luminária: 170 mm; Altura do conector: 26 mm; Altura do Spot: 100 mm; Comprimento do conector: 120 mm; Diâmetro do spot: 45 mm
Type - Dados - Data de atualização: 15/05/2025; Versão: 1
Type - Dados de identidade - Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Módulo LED magnetic Track Kay In, acabamento branco, 18W 3000K 24º; Desenvolvedor: Check BIM; Fabricante: Nordecor; Garantia: 2 Anos; IP: 20; Localização: Camboriú-SC / Brasil; Modelo: 6710; Nome do tipo: 6710; Número OmniClass: 23.80.70.11.14.21; Tipo de imagem: Imagem raster: 6710.png; Título OmniClass: Spots and Tracklight Specialties; URL: https://nordecor.com.br; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/spot-led-magnetic-track-kay-in-18w-3-000k/
Type - Elétrico - Comentários de voltagem: DC48V; Lâmpada: LED
Type - Elétrico - Cargas - Carga aparente - Luminária: 0 W
Type - Engenharia elétrica - Fator de potência - Luminária: 1; Voltagem - Luminária: 0 V
Type - Estrutural - Peso da luminária: 0
Type - Fotométricos - Ângulo de abertura: 24 deg; Fluxo luminoso: 1400 lm; IRC: 90; Potência: 18 W; Temperatura de cor: 3000 K
Type - Gráficos - Simbologia: Imagem raster: 6710 2D.png
Type - Materiais e acabamentos - Difusor: Plástico - Transparente; Luminária: Metal - Alumínio - Branco
Type - Outros - Categoria: Luminárias; Branco: yes; Nome da família: Módulo_Track_KayIn_6558_6710_Nordecor_IFC; Preto: no
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes
Pset_DistributionFlowElementCommon - Reference: 6710; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Nordecor
Cotas - Ângulo de inclinação: 0 deg; Área: 0.0270932 m2; Rotação: 0 deg; Volume: 0.000314567 m3
Dados de identidade - Marca: 1
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Módulo_Track_KayIn_6558_6710_Nordecor_IFC: 6710; Família e tipo: Módulo_Track_KayIn_6558_6710_Nordecor_IFC: 6710; ID de tipo: Módulo_Track_KayIn_6558_6710_Nordecor_IFC: 6710; Incl. real: 0 deg; Tipo: Módulo_Track_KayIn_6558_6710_Nordecor_IFC: 6710
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
